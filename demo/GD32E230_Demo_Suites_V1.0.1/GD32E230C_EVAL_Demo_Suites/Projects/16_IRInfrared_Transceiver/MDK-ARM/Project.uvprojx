# Keil uVision project Project.uvprojx, settings and files
target GD32E230C_EVAL (6100001::V6.10.1::.\ARMCLANG)
  device: GD32E230C8 GigaDevice
  pack: GigaDevice.GD32E230_DFP.1.0.0
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: GD32E230C_EVAL
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E230
  c include: ..\..\..\..\GD32E230_Firmware_Library\CMSIS\GD\GD32E230\Include;..\..\..\Utilities;..\;..\..\..\..\GD32E230_Firmware_Library\CMSIS;..\..\..\..\GD32E230_Firmware_Library\GD32E230_standard_peripheral\Include;..\Soft_Drive
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application
    ../: gd32e230_it.c main.c systick.c
  group CMSIS
    ../../../../GD32E230_Firmware_Library/CMSIS/GD/GD32E230/Source/: system_gd32e230.c
  group GD32E230_Peripherals
    ../../../../GD32E230_Firmware_Library/GD32E230_standard_peripheral/Source/: gd32e230_adc.c gd32e230_cmp.c gd32e230_crc.c gd32e230_dbg.c gd32e230_dma.c gd32e230_exti.c gd32e230_fmc.c gd32e230_fwdgt.c gd32e230_gpio.c gd32e230_i2c.c gd32e230_misc.c gd32e230_pmu.c gd32e230_rcu.c gd32e230_rtc.c gd32e230_spi.c gd32e230_syscfg.c gd32e230_timer.c gd32e230_usart.c gd32e230_wwdgt.c
  group GD32E230_EVAL
    ../../../Utilities/: gd32e230c_eval.c
  group Soft_Drive
    ../Soft_Drive/: rc5_decode.c rc5_encode.c
  group Startup
    ../../../../GD32E230_Firmware_Library/CMSIS/GD/GD32E230/Source/ARM/: startup_gd32e230.s
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.0.2
