# Keil uVision project USBH_MSC.uvproj, settings and files
target USBFS_MSC_HOST (ARM-ADS)
  device: GD32F207IK GigaDevice
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x08000000-0x082FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: USBH-MSC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USBFS,GD32F20X_CL
  c include: ..\inc;..\..\..\..\..\Firmware\CMSIS\GD\GD32F20x\Include;..\..\..\..\..\Firmware\GD32F20x_standard_peripheral\Include;..\..\..\..\..\Firmware\GD32F20x_usbfs_driver\Include;..\..\..\..\..\Utilities\LCD_common;..\..\..\..\..\Utilities;..\..\..\..\..\Utilities\Third_Party\fat_fs\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Application
    ../src/: main.c usb_delay.c gd32f20x_it.c usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c usbh_usr.c systick.c
  group CMSIS
    ../../../../../Firmware/CMSIS/GD/GD32F20x/Source/: system_gd32f20x.c
  group GD32F20x_StdPeriph_Driver
    ../../../../../Firmware/GD32F20x_standard_peripheral/Source/: gd32f20x_exmc.c gd32f20x_exti.c gd32f20x_gpio.c gd32f20x_misc.c gd32f20x_pmu.c gd32f20x_rcu.c gd32f20x_timer.c gd32f20x_tli.c gd32f20x_usart.c
  group GD32F20x_EVAL
    ../../../../../Utilities/LCD_common/: lcd_font.c lcd_log.c
    ../../../../../Utilities/: gd32f20x_lcd_eval.c gd32f20x_sdram_eval.c
    ../src/: gd32f207i_eval.c
  group FAT_FS
    ../../../../../Utilities/Third_Party/fat_fs/src/: fattime.c ff.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32F20x/Source/ARM/: startup_gd32f20x_cl.s
  group USB_Driver
    ../../../../../Firmware/GD32F20x_usbfs_driver/Source/: usb_core.c usbh_core.c usbh_ctrl.c usbh_hcs.c usbh_int.c usbh_std.c
  group Doc
    ../: readme.txt
