# IAR project Project.ewp, settings and files
configuration GD32E230 (ARM, debug)
  General.OGChipSelectEditMenu: GD32E230x8 GD GD32E230x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: GD32E230
  ICCARM.CCIncludePath2: ..\..\..\..\GD32E230_Firmware_Library\CMSIS\GD\GD32E230\Include; ..\..\..\..\GD32E230_Firmware_Library\GD32E230_standard_peripheral\Include; ..\..\..\Utilities; ..; ..\Soft_Drive; ..\..\..\Utilities\LCD_Common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../: gd32e230_it.c main.c systick.c
  group CMSIS
    ../../../../GD32E230_Firmware_Library/CMSIS/GD/GD32E230/Source/: system_gd32e230.c
  group Doc
    ../: readme.txt
  group GD32E230_EVAL
    ../../../Utilities/: gd32e230c_eval.c gd32e230c_lcd_eval.c
  group GD32E230_Peripherals
    ../../../../GD32E230_Firmware_Library/GD32E230_standard_peripheral/Source/: gd32e230_adc.c gd32e230_cmp.c gd32e230_crc.c gd32e230_dbg.c gd32e230_dma.c gd32e230_exti.c gd32e230_fmc.c gd32e230_fwdgt.c gd32e230_gpio.c gd32e230_i2c.c gd32e230_misc.c gd32e230_pmu.c gd32e230_rcu.c gd32e230_rtc.c gd32e230_spi.c gd32e230_syscfg.c gd32e230_timer.c gd32e230_usart.c gd32e230_wwdgt.c
  group Soft_Drive
    ../Soft_Drive/: tft_test.c tft_test.h
  group Startup
    ../../../../GD32E230_Firmware_Library/CMSIS/GD/GD32E230/Source/IAR/: startup_gd32e230.s
