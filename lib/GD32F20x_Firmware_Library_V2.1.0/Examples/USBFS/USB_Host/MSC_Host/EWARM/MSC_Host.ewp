# IAR project MSC_Host.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32F20xxK GD GD32F20xxK
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USBFS; GD32F20X_CL
  ICCARM.CCIncludePath2: ..\..\..\..\..\Firmware\CMSIS\GD\GD32F20x\Include; ..\..\..\..\..\Firmware\GD32F20x_standard_peripheral\Include; ..\..\..\..\..\Firmware\GD32F20x_usbfs_driver\Include; ..\inc; ..\..\..\..\..\Utilities\LCD_common; ..\..\..\..\..\Utilities; ..\..\..\..\..\Utilities\Third_Party\fat_fs\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBH_MSC.srec
  ILINK.IlinkOutputFile: USBH_MSC.hex
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: gd32f20x_it.c main.c systick.c usb_delay.c usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c usbh_usr.c
  group CMSIS
    ../../../../../Firmware/CMSIS/GD/GD32F20x/Source/: system_gd32f20x.c
  group Doc
    ../: readme.txt
  group FAT_FS
    ../../../../../Utilities/Third_Party/fat_fs/src/: fattime.c ff.c
  group GD32F20x_EVAL
    ../src/: gd32f207i_eval.c
    ../../../../../Utilities/: gd32f20x_lcd_eval.c gd32f20x_sdram_eval.c
    ../../../../../Utilities/LCD_common/: lcd_font.c lcd_log.c
  group GD32F20x_Peripherals
    ../../../../../Firmware/GD32F20x_standard_peripheral/Source/: gd32f20x_exmc.c gd32f20x_exti.c gd32f20x_gpio.c gd32f20x_misc.c gd32f20x_pmu.c gd32f20x_rcu.c gd32f20x_timer.c gd32f20x_tli.c gd32f20x_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32F20x/Source/IAR/: startup_gd32f20x_cl.s
  group USB_Driver
    ../../../../../Firmware/GD32F20x_usbfs_driver/Source/: usb_core.c usbh_core.c usbh_ctrl.c usbh_hcs.c usbh_int.c usbh_std.c
